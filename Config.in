## package/python-mpio/Config.in
```kconfig
config BR2_PACKAGE_PYTHON_MPIO
	bool "python-mpio"
	help
	  Hardware access for Microchip boards.

	  
```
